# Keil uVision project scheduler.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103C4 STMicroelectronics
  cpu: IRAM(0x20000000-0x200017FF) IROM(0x8000000-0x8003FFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: scheduler +hex
  c flags: Optim=1
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1800
  group Source Group 1
    ./: startup_stm32f10x_ld.s system_stm32f10x.c
  group MCAL
    ./: RCC_program.c STK_program.c DIO_program.c
  group OS
    ./: OS_program.c
  group APP
    ./: main.c
